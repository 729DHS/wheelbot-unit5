## boards/dji/robomaster_c/Kconfig.robomaster_c
```kconfig
# SPDX-License-Identifier: Apache-2.0

config BOARD_ROBOMASTER_C
	select SOC_STM32F407XG
```
